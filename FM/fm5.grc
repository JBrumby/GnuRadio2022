options:
  parameters:
    generate_options: qt_gui
    id: FM_5
    output_language: python
    title: Test mit hackrf und pluto gleichzeitig
  states: {}

blocks:
- name: agc
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: automatic gain Control
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: bbamp
  id: variable_qtgui_range
  parameters:
    label: Baseband-Verstärkung
    start: '0'
    step: '1'
    stop: '47'
    value: '24'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frrequenz
    start: 88e6
    step: 1e4
    stop: 108e6
    value: freq1
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 89.0e6
  states: {}
- name: ifamp
  id: variable_qtgui_range
  parameters:
    label: IF Zwischenfrequenz Verstärkung
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: rfamp
  id: variable_qtgui_range
  parameters:
    label: Eingangsverstärkung
    start: '0'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '.2'
    stop: '5'
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters:
    alias: DC
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e5
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Hier wird im ersten Schritt festglegt, wie 
      - das erzeugte Programm heißt
      - wie der Name des Programms im Hauptfenster sein soll
      - in welche Sprache das Programm übersetzt werden soll (Python oder C++)
      - welches libraries für die grafische Darstelung benutzt werden sollen (QT, wx, none)
    note: Programm-Optionen
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Jeder Gnu Radio Block arbeitet mit einer festen Sample_rate. 
      Sie muss an die Leistung des Rechners angepasst werden, damit sich das Programm nicht verschluckt.

      Wenn ein Programm gestartet ist, kann man unten links in der Textausgabe sehen, 
      ob der Computer schnell genug für die Verarbeitung ist, je mehr 'UO' auftauchen desto mehr Datenpakete gehen verloren.
    note: Bandbreite
  states: {}
- name: note_10
  id: note
  parameters:
    comment: |-
      In diesem Block, werden nun Frequenzänderungen in Pegeländerungen umgewandelt.

      Seine sampling rate muss eingestellt auf die sampling_rate (Bandbreite) eingestellt werden, die aus dem vorhergehenden Block kommt.
      Also: 
      - der  Empfangsblock hat die Bandbreite "samp_rate"
      - der Tiefpass hat enen eingebauten Resampler, der de Datenrate decimation 4 auf auf ein viertel reuziert.
      Also Empfängerbandbreite 2 MHz, Decimation 4 ergibt eine sampling_rate = Quadratur-rate von 500KHz

      In diesem Block ist ebenfalls ein Resampler eingebaut, der mit der EInstellung 10 für decimation die Eingangsdatenrate von 500Hz auf 50 KHz umrechnet.
    note: FM-Decoder
  states: {}
- name: note_11
  id: note
  parameters:
    comment: wenn dieses Gui-Element "enabled" wird, sieht man die reduzierte Bandbreiite mit den übriggebliebenen Nutzdaten.
  states: {}
- name: note_12
  id: note
  parameters:
    comment: |-
      Mit diesem Resampler wird die Datenraten von 50KHz auf die sampling_rate von 48khz deer Soundkarte umgerechnet.
      Dazu wird durch 50 geteilt und dann 48 multipliziert.
  states: {}
- name: note_13
  id: note
  parameters:
    comment: |-
      Durch diesen Mulitplyer kann die Lautsärke des Signals  eingestellt werden.
      1 = ohne Verstärkung / Abschwächung
  states: {}
- name: note_14
  id: note
  parameters:
    comment: Hier ist nun endlich die Eingangsbandbreite des Empfängers auf die Bandbreite des Der Soundkarte heruntergerechnet.
  states: {}
- name: note_15
  id: note
  parameters:
    comment: |-
      It is not necessary to identify the SDR if only one is connected to the 
      processing board. For the gains, it is necessary to make tests to find 
      the good values according to the model of SDR.

      Note On Hack RF Gains
      HackRF One provides:
      RX : three different analog gain controls
      RF (“amp”, 0 or 14 dB),
      IF (“lna”, 0 to 40 dB in 8 dB steps),
      baseband (“vga”, 0 to 62 dB in 2 dB steps)
      TX : two gain controls
      RF (0 or 14 dB) ,
      IF (0 to 47 dB in 1 dB steps)

      (https://f1atb.fr/index.php/2020/08/06/hackrf-orange-pi-gnuradio-setup/)

      Alle Verstärkungen rf, f und bb auf 0 bringen erste Erfolge

      ff: 0
      if 20
      bb 24
      Aussderm liegt mein hackrf sehr neben der Spur ungefähr 700khz ??, Jetzt geht es.
      funktioniert!
      eine RF = 14 erzeugt KEIEN Verstärkung bei mir, sondern es rauscht nur. Das heist rg geht bei nur von 0-13
  states: {}
- name: note_16
  id: note
  parameters:
    comment: |-
      Remove DC-Spike ist die Lösung überhaupt etwas auf der centerfrequenz 
      zu emofangen. d.b. Meine Konzept ohne Mischer, der einen  
      Frequenzoffset neben der Centerfrequenz einstellt hat, mir das Bein gestellt.

      https://www.rtl-sdr.com/wp-content/uploads/2017/02/Getting-rid-of-that-center-frequency-spike-in-gnuradio_07.pdf

      Heureka

      Diese Lösung genügt aber nicht, um dden Empfang hier völling stürungsfrei 
      zu machen. dazu muss mann neben die Null-Herz Stelle abstimmen.
  states: {}
- name: note_17
  id: note
  parameters:
    comment: |-
      Diese Einstsellregler erzeugen Variablen, die in diesem Programm
      nur für "Osmocon Source" verwendet werden, um dem Problem
      des nicht funktionierenden Empfangs auf die Spur zu kommen.
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      Sampling-Rate muss für jeden Block stimmen!

      Die Bandbreite des Empfangsblocks bestimmt nach der Nyquist-Rate
      wie breit der Empfangsbereich des SDR ist.
      Also wie breit der Frequenzbereich der auf einmal empfangen werden kann und optisch im Frequenz-Wasserfalls dargestellt werden kann.
    note: Sampling-Rate muss für jeden Block stimmen!
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      Ich bin oft bei meinen Gnu Radio Experimenten gescheitert, weil
      die Beispiele nicht funktionierten.
      Es kam einfach kein Audio aus dem Beispiel und ich wusste nicht woaran das liegt.

      Kurz gesagt liegt es daran, dass entweder:
      - die Sample-Rates der verschiedenen Blocks nicht zusammen passen
      - oder, dass die Ein- und Ausgangspegel der Blocks nicht zusamme passen
      - dass mein Rechner zu schwachbrüstig war für die optimistischen Einstellungen des Erstellers eines Beispiel

      Lösungen:
      -  Ich reduziere die Bandbreite möglichst weit, damit das Programm auch auf langsamer Harware läuft.
      -  Ich berechne die Sampling-rate der verschiedenen Stufen und mache sie so voneinander abhängig.
      also wenn wir von einer samplingrate on 48Khz (48e3) ausgehen können,
      ergibt sich sampling-rate des Empfangsmoduls das in der Kette davor steht als ein ganzzahliges vielfaches davon. 
      zum Beispiel: samp_rate= 10 * audio_samp_rate

      Die Sampling-rate eines Blocks muss auf die Sampling-Raate des nächsten folgenden Blocks umgerechnet werden. 
      - In manchen Blocks kann man das einstellen (decimation und multiply)
      - oder es wird ein "rational resampler" dazwischen gesetzt, der genau diese Umrechnung vornimmt.
    note: welchen Empfangsblock benötige ich?
  states: {}
- name: note_4
  id: note
  parameters:
    comment: |-
      Bei einem SDR wird die Gesamtbandbreite des Empfängersr auf einen Wasserfall gegeben, 
      damit man sieht, wo im Empfangsbereich intererssante Sgnale sind. 
      (Siehe direkter Anschluss des Blocks "QT-Gui-Sink" an den Empfangsblock)

      Normalerweise würde dann ein Mischer folgen, der bei feststehender Center-Frequence des Wasserfalls 
      das gewünschte Signal durch Mischung in den Bereich des Tiefpassfilters holt. 
      In diesem Design ist der Mischer nicht eingebaut, um das Progamm möglichst einfach zu halten.
    note: Beispiel-Design
  states: {}
- name: note_5
  id: note
  parameters:
    comment: |-
      Hier wird die gewünschte Frequenz eingestellt, auf die der Empfänger bei Programmstart eingestellt wird.
      89.0MHz ist bei mir einfach der stärkste Lokalsender
    note: freq1
  states: {}
- name: note_6
  id: note
  parameters:
    comment: |-
      Hier wird ein Schieberegler erzeugt, mit dem man die Empfangsfrequenz des radios einstellen kann.
      Das Ergebnis wird als Vairable mit der ID: freq bereit gestellt.
    note: Abstimmbereich
  states: {}
- name: note_7
  id: note
  parameters:
    comment: |-
      Durch anklicken eines der drei Empfängerblocks kann mit einem Rechtsklick
      einer der Blöcke "enabled" wwerden. Die anderen müssen disablet werden, sonst kann das 
      Programm nicht mehr kompiliert werden, weil dem einem Eingang des Low-Pass-Filters mehrere Ausgänge zugeordnet sind.
    note: Auswahl Empfänger
  states: {}
- name: note_8
  id: note
  parameters:
    comment: |-
      Der Empfangsblock hat die Centerfrequenz bereits auf 0 Hz heruntergerechnet,  
      Wir haben also einen Bereich der Bandbreite samling_rate in und der frequenz freq umgerechnet in den Bereich centerfreq - ceenter_frequ = 0Hz heruntergerechnet.
      Die Bandbreite (samp_rate) blieb dabei komplett erhalten.

      wir filtern mit dem Teifpass alles weg, was wir nicht benötigen.
      Wir erhalten daraus einen Frequenzband mit der Bandbreite samp_rate in dem beii voller Datenrate nur die Daten in den Frequenzen fehlen, die wir herausgefiltert haben.

      später kann dann mit einem Resampler die Banndbreite des Signals verkleinert werden, damit der Rechner von der Bearbetung dieser jeetzt fehlenden Daten  zu befreien.
      (Nur weil in einem übertragenen Frequenzband keine Signale mehr sind, wir das Frequenzband trotzdem in seiner gesamten Breite weitergegeben und muss verarbetet werden. Dei tatsächnlcihe Reduzierung
      findet erst durch das resamplen statt.

      Achtung: im "Low-pass-Filter" ist eine resampler enthalten. Der ist hier auf eine Teilugsrate von 4 eingestellt. Aus diesem speziellen Filter kommt damit bereits nur noch ein viertel der Bandbreite!

      Warum den Filter?
      Da die Bandbreite eines Signals in direktem Zusammenhang mit der übertragbaren Frequenz steht, würde bei der nachfolgenden Umrechnen der Sampling_rate ohne Filter rein zufällige Pegel aus den höheren Frequenzen durch die neue Abtastrate auf
      das Nutzsignal aufgetragen. Durch das Filter sind diese Daten weg und können so das Ausgangssignal nicht mehr beeinflussen.

      Ich habe hieir mit dem Gain-Multiplikater = 0.7 die Signalstärker eduziert, weil bei mir das Empfangssignal völlig übersteuert war. Ich bin mir nicht sicher, ob das nicht schon im Empfangsblock hätte passieren müssen. 
      Dort hatte ich jedoch AGC eingestellt, deshalb sollte die Stärke der Signale dort passen.
    note: Low-Pass-Filter
  states: {}
- name: note_9
  id: note
  parameters:
    comment: Der Empfangsblock verschiebt wie ein Direktmischer den empfangenenen Bereich mit der Bandbreite samp_rate von der centerfrequenz "freq" nach 0 Hz.
    note: Frequenz des Empfangsblocks
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: bbamp
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rfamp
    gain_mode0: agc
    if_gain0: ifamp
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    grid: 'True'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: Gesamtbandbreite nach dem Empfangsblock
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/4
    fc: freq1/4
    fftsize: '1024'
    name: Nach dem Filter
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: '1'
    center_freq: freq
    dev_args: ip:pluto.local
    gain: '45'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_correctiq_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_histogram_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_xx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1

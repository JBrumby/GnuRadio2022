options:
  parameters:
    generate_options: qt_gui
    id: FM_5
    output_language: python
    title: Test mit hackrf und pluto gleichzeitig
  states: {}

blocks:
- name: agc
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: hfamps@1:0,0,1,1
    label: automatic gain Control
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: bbamp
  id: variable_qtgui_range
  parameters:
    gui_hint: hfamps@0:2,0,1,1
    label: Baseband-Verstärkung
    start: '0'
    step: '1'
    stop: '47'
    value: '24'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Frrequenz
    start: 88e6
    step: 1e4
    stop: 108e6
    value: freq1
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 89.0e6+3e4
  states: {}
- name: ifamp
  id: variable_qtgui_range
  parameters:
    gui_hint: hfamps@0:1,0,1,1
    label: IF Zwischenfrequenz Verstärkung
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: rfamp
  id: variable_qtgui_range
  parameters:
    gui_hint: hfamps@0:0,0,1,1
    label: Eingangsverstärkung
    start: '0'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Lautstärke
    start: '0'
    step: '.2'
    stop: '5'
    value: '0.2'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters:
    alias: DC
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: volume
    type: float
  states: {}
- name: hfamps
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,1
    label0: HF-Verstärkung manuell
    label1: HF-Verstärkung automataisch
    num_tabs: '2'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e5
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Diese Plan ist das Ergebnis von der Arbeit 
      aus dem Verzeichnis 1. FM

      Zum Verstehen der einzenen Blöcke bitte dort nachsehen.
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      In diesem Flussplan geht es darum, 
      die Oberfläche des Programms aufzuräumen
      indem die Gui-Elemente angeordnet werden.

      das passiert über die Variable "gui-hint"
      The format is:

      (row, column, row span, column span)

      row, colum >= 0
      row span, column span >= 1

      siehe: https://wiki.gnuradio.org/index.php/GUI_Hint

      Das Konzept erscheint mir so einfach, dass kaum Erklärung bedaarf.

      Die erste Zahl gibt an in welcher Reihe das Element stehen soll.
      Die zweite Zahl gibt an in welcher Spalte das Element stehn soll.
      die dritte gibt an, über wieviele Spalten sich ein Element erstrecken soll, 
      die vierte Zahl gibt an, wieviel Reihen übereinander eingenommen werden soll.

      Das ganze entsteht dynamisch es muss nichts vorab konfiguriert werden

      Man kann mehrere Elemente in einem "QT-Gui-Tab-Widget"-Block zusamen fassen.
      mit dem Gui Hint kann ebenfalls adressiert werden in welchem Tab von welcher Box sich das Element befindetn soll.
      Außer diesen beiden Gestaltungsmöglichkeiten: Raster und Zusammenfassung eines Rasters von Elementen in Tabs 
      gibt es keine grafischen Gestaltungsmöaglichkeiten.
      Eine Box ist ein QT-gui-tabbed Widget mit nur einem Tab. Na ja. Wenig,  genügt aber.
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: bbamp
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rfamp
    gain_mode0: agc
    if_gain0: ifamp
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    grid: 'True'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: Gesamtbandbreite nach dem Empfangsblock
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/4
    fc: freq1/4
    fftsize: '1024'
    name: Nach dem Filter
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: '1'
    center_freq: freq
    dev_args: ip:pluto.local
    gain: '45'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_correctiq_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_histogram_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_xx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
